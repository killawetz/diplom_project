# Keil uVision project datchik.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Milandr.MDR1986BExx.1.4.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: datchik
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\Milandr_Config;..\..\..\Library\Milandr_Interrupt
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c MPU9250.c MPU9250.h
    ./LCD_lib/: font.h lcd.c lcd.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.3.1, Drivers:I2C 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:TIMER 1.3.1
